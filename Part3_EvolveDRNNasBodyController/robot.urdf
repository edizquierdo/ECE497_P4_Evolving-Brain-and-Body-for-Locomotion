Commit message: Update to add sensors and motor weights

File: Part3_EvolveDRNNasBodyController/robot.urdf (robot description, URDF)
Before this commit: robot robot, 3 links, 2 joints
Joints:
- joint 0_1: origin xyz=0.5 0 1 rpy=0 0 0 -> xyz=0.5 0 2 rpy=0 0 0
